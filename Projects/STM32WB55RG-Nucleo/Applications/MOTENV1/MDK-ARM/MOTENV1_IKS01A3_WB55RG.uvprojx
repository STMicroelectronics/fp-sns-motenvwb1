# Keil uVision project MOTENV1_IKS01A3_WB55RG.uvprojx, settings and files
target MOTENV1_IKS01A3_WB55RG (6180000::V6.18::ARMCLANG)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: MOTENV1_IKS01A3_WB55RG +hex
  AfterMake: fromelf #L --bincombined --output=@L.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_IKS01A3,USE_HAL_DRIVER,STM32WB55xx
  c misc: -Wno-format
  c include: ../Core/Inc;../STM32_WPAN/App;../X-CUBE-MEMS1/Target;../../../../../Drivers/STM32WBxx_HAL_Driver/Inc;../../../../../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy;../../../../../Utilities/lpm/tiny_lpm;../../../../../Middlewares/ST/STM32_WPAN;../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread;../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl;../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci;../../../../../Middlewares/ST/STM32_WPAN/utilities;../../../../../Middlewares/ST/STM32_WPAN/ble/core;../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto;../../../../../Middlewares/ST/STM32_WPAN/ble/core/template;../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Inc;../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src;../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../../../../../Utilities/sequencer;../../../../../Middlewares/ST/STM32_WPAN/ble;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/BSP/Components/lsm6dso;../../../../../Drivers/BSP/Components/lis2dw12;../../../../../Drivers/BSP/Components/lis2mdl;../../../../../Drivers/BSP/Components/hts221;../../../../../Drivers/BSP/Components/lps22hh;../../../../../Drivers/BSP/Components/stts751;../../../../../Drivers/BSP/IKS01A3;../../../../../Drivers/BSP/Components/Common;../../../../../Middlewares/ST/STM32_MotionFX_Library/Inc;../../../../../Middlewares/ST/STM32_MotionAR_Library/Inc;../../../../../Middlewares/ST/STM32_MotionAW_Library/Inc;../../../../../Middlewares/ST/STM32_MotionCP_Library/Inc;../../../../../Middlewares/ST/STM32_MotionGR_Library/Inc;../../../../../Middlewares/ST/STM32_MotionPM_Library/Inc;../../../../../Middlewares/ST/STM32_MotionID_Library/Inc;../X-CUBE-TOF1/Target;../../../../../Drivers/BSP/53L3A2;../../../../../Drivers/BSP/Components/vl53l3cx/modules;../../../../../Drivers/BSP/Components/vl53l3cx/porting;../../../../../Drivers/BSP/Components/vl53l3cx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: motenv_server_app.c env_server_app.c ToF_server_app.c motion_server_app.c motion_ext_server_app.c motionfx_server_app.c motionar_server_app.c motionaw_server_app.c motioncp_server_app.c motiongr_server_app.c motionpm_server_app.c motionid_server_app.c config_server_app.c console_server_app.c MotionAR_Manager.c MotionAW_Manager.c MotionCP_Manager.c MotionFX_Manager.c MotionGR_Manager.c MotionID_Manager.c MotionPM_Manager.c app_ble.c p2p_server_app.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Application/User/Core
    ../Core/Src/: main.c app_entry.c app_debug.c hw_timerserver.c hw_uart.c stm32_lpm_if.c stm32wbxx_nucleo_bus.c stm32wbxx_it.c stm32wbxx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso_reg.c lsm6dso.c
    ../../../../../Drivers/BSP/Components/lis2dw12/: lis2dw12_reg.c lis2dw12.c
    ../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl_reg.c lis2mdl.c
    ../../../../../Drivers/BSP/Components/hts221/: hts221_reg.c hts221.c
    ../../../../../Drivers/BSP/Components/lps22hh/: lps22hh_reg.c lps22hh.c
    ../../../../../Drivers/BSP/Components/stts751/: stts751_reg.c stts751.c
    ../../../../../Drivers/BSP/Components/vl53l3cx/modules/: vl53lx_api.c vl53lx_api_calibration.c vl53lx_api_core.c vl53lx_api_debug.c vl53lx_api_preset_modes.c vl53lx_core.c vl53lx_core_support.c vl53lx_dmax.c vl53lx_hist_algos_gen3.c vl53lx_hist_algos_gen4.c vl53lx_hist_char.c vl53lx_hist_core.c vl53lx_hist_funcs.c vl53lx_nvm.c vl53lx_nvm_debug.c vl53lx_register_funcs.c vl53lx_sigma_estimate.c vl53lx_silicon_core.c vl53lx_wait.c vl53lx_xtalk.c
    ../../../../../Drivers/BSP/Components/vl53l3cx/porting/: vl53lx_platform.c vl53lx_platform_ipp.c vl53lx_platform_log.c
    ../../../../../Drivers/BSP/Components/vl53l3cx/: vl53l3cx.c
  group Drivers/BSP/IKS01A3
    ../../../../../Drivers/BSP/IKS01A3/: iks01a3_motion_sensors.c iks01a3_motion_sensors_ex.c iks01a3_env_sensors.c iks01a3_env_sensors_ex.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c stm32wbxx_hal_crc.c stm32wbxx_hal_crc_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Middlewares/STM32_WPAN
    ../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: tl_mbox.c hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c
    ../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
    ../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
    ../../../../../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
    ../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
    ../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: p2p_stm.c svc_ctl.c motenv_stm.c
  group Middlewares/STM32_MotionAR_Library
    ../../../../../Middlewares/ST/STM32_MotionAR_Library/Lib/: MotionAR_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionAW_Library
    ../../../../../Middlewares/ST/STM32_MotionAW_Library/Lib/: MotionAW_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionCP_Library
    ../../../../../Middlewares/ST/STM32_MotionCP_Library/Lib/: MotionCP_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionFX_Library
    ../../../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionGR_Library
    ../../../../../Middlewares/ST/STM32_MotionGR_Library/Lib/: MotionGR_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionID_Library
    ../../../../../Middlewares/ST/STM32_MotionID_Library/Lib/: MotionID_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionPM_Library
    ../../../../../Middlewares/ST/STM32_MotionPM_Library/Lib/: MotionPM_CM4F_wc16_ot.a
  group Utilities
    ../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../Utilities/sequencer/: stm32_seq.c
  group Drivers/BSP/53L3A2
    ../../../../../Drivers/BSP/53L3A2/: 53l3a2.c 53l3a2_ranging_sensor.c
  group Middlewares/X-CUBE-TOF1/Documentation
    ../../../../../Drivers/BSP/53L3A2/: LICENSE.txt
    ../../../../../Drivers/BSP/Components/vl53l3cx/: LICENSE.txt
    ../../../../../Drivers/BSP/Components/vl53l3cx/modules/: LXReleaseNotes.txt
software components: CMSIS:CORE 5.6.0
