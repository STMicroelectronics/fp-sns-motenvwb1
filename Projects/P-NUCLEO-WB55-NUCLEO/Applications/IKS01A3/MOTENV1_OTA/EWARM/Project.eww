<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MOTENV1_OTA.ewp</path>
  </project>
  <batchBuild />
</workspace>
